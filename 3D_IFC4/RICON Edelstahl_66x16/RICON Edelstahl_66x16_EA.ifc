Properties of the parts of a building model (IFC4)

# File
Description: Unknown
File name: RICON Edelstahl_66x16_EA
Time: 2022-02-07T12:19:25+01:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v16.7
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcSite, Default Site
RefElevation: 0 mm

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingStorey, Default Building Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: RICON_16x66 (2)
In: Default Building Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SK_Schraube_5x50 (3)
In: Default Building Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SK_Schraube_5x80 (3)
In: Default Building Storey
PredefinedType: ELEMENT
