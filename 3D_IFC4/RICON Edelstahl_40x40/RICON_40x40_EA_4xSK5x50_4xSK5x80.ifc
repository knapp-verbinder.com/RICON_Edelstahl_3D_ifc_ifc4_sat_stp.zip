Properties of the parts of a building model (IFC4)

# File
Description: Unknown
File name: RICON_40x40_EA_4xSK5x50_4xSK5x80
Time: 2022-03-08T11:16:21+01:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v16.7
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcSite, Default Site
RefElevation: 0 mm

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingStorey, Default Building Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: RICON_40x40_Gegenteil_reduzierte Darstellung
In: Default Building Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: RICON_40x40_reduzierte Darstellung
In: Default Building Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Z533_SK_Schraube_5x50_Ricon_reduzierte Darstellung (4)
In: Default Building Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Z534_SK_Schraube_5x80_Ricon_reduzierte Darstellung (4)
In: Default Building Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: sperre_RICON_40
In: Default Building Storey
PredefinedType: ELEMENT
